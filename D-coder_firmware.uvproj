# Keil uVision project D-coder_firmware.uvproj, settings and files
target Target 1 (MCS-51)
  device: R80515 Evatronix
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MODC2 MDU_R515
  output: BAT601_firmware +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./src/: isr.c main.c STARTUP.A51 uart.c timer.c flashStartup.a51 uart_ui.c flashmark.c spiflash.c dcode.c hostif.c
  group include
    ./src/: uart.h syscfg.h update.h
